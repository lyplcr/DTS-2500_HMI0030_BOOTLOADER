# Keil uVision project PCM.uvproj, settings and files
target PRM (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PCM +hex
  AfterMake: fromelf --bin -o ..\BIN\DTS-2500_HMI0030_BOOT(SY0120)_150927.bin ..\OUTPUT\OBJ\PCM.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\CORE;..\BSP\inc;..\FWLIB\inc;..\FATFS;..\utils;..\APP\inc;..\LWIP-1.3.1\port;..\LWIP-1.3.1\src\include;..\LWIP-1.3.1\src\include\lwip;..\LWIP-1.3.1\src\include\ipv4;..\USB\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\Libraries\STM32_USB_HOST_Library\Core\inc;..\USB\Libraries\STM32_USB_OTG_Driver\inc;..\USB\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../APP/src/: main.c
  group APP
    ../APP/src/: SD_UpDate.c USB_UpDate.c tftpserver.c flash_if.c
  group BSP
    ../BSP/src/: key.c timer.c sdio_sd.c lcd.c RA8875.c usb.c date.c pcf8563.c flash.c lan8720.c netconf.c
    ../USB/USB_APP/: usb_bsp.c usbh_it.c usbh_usr.c
  group UTILS
    ../utils/: isqrt.c ustdlib.c ustring.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_flash.c stm32f4x7_eth.c
  group USB
    ../USB/Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../USB/Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: ccsbcs.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group LWIP
    ../LWIP-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../LWIP-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../LWIP-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP-1.3.1/src/netif/: etharp.c
    ../LWIP-1.3.1/port/: ethernetif.c
  group Doc
    ../Doc/: 修改日志.txt 问题记录.txt
    ../APP/inc/: config.h
